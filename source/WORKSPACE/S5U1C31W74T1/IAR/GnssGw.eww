<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\sePeriphLibrary\Device\S1C31W74\IAR\sePeriphLibrary.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\GNSS_GW\board\S5U1C31W74T1\IAR\GNSS_GW.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all_Debug</name>
      <member>
        <project>seGraphicsLibrary</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>sePeriphLibrary</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>T16</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>WDT2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>RTCA</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>I2C</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>QSPI</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>RFC</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SNDA</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>T16B</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>CLG</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>LCD32B</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>QSPI_DMA</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>REMC2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SVD2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>QSPI_MASTER</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>QSPI_SLAVE</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SPIA_MASTER</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>SPIA_SLAVE</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>UART2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>PPORT</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>DMAC</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>GNSS_GW</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>USB_CDC</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>USB_HID_S5U1C31W74T1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>USB_MSC</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>all_DebugFlash</name>
      <member>
        <project>seGraphicsLibrary</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>sePeriphLibrary</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>CLG</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>I2C</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>LCD32B</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>QSPI</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>QSPI_DMA</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>QSPI_MASTER</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>QSPI_SLAVE</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>REMC2</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>RFC</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>RTCA</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>SNDA</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>SPIA_MASTER</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>SPIA_SLAVE</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>SVD2</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>T16</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>T16B</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>UART2</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>WDT2</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>PPORT</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>DMAC</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>GNSS_GW</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>USB_CDC</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>USB_HID_S5U1C31W74T1</project>
        <configuration>DebugFlash</configuration>
      </member>
      <member>
        <project>USB_MSC</project>
        <configuration>DebugFlash</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>all_ReleaseFlash</name>
      <member>
        <project>seGraphicsLibrary</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>sePeriphLibrary</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>CLG</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>I2C</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>LCD32B</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>QSPI</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>QSPI_DMA</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>QSPI_MASTER</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>QSPI_SLAVE</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>REMC2</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>RFC</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>RTCA</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>SNDA</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>SPIA_MASTER</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>SPIA_SLAVE</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>SVD2</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>T16</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>T16B</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>UART2</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>WDT2</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>PPORT</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>DMAC</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>GNSS_GW</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>USB_CDC</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>USB_HID_S5U1C31W74T1</project>
        <configuration>ReleaseFlash</configuration>
      </member>
      <member>
        <project>USB_MSC</project>
        <configuration>ReleaseFlash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



# IAR project GNSS_GW.ewp, settings and files
configuration DebugFlash (ARM, debug)
  General.OGChipSelectEditMenu: S1C31W74 Epson S1C31W74
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __TARGET_ARCH_7_M; S1C31W74; GNSS_GW_SIDE_A
  ICCARM.CCDiagSuppress: Pe177, Pe111,Pa082
  ICCARM.CCIncludePath2: ; ..\..\..\; $TOOLKIT_DIR$\CMSIS\Include\; $TOOLKIT_DIR$\inc\Epson\; ..\..\..\..\..\CMSIS\Device\S1C31W74\Include; ..\..\..\..\..\CMSIS\Driver\Include\; ..\..\..\..\..\sePeriphLibrary\; ..\..\..\..\..\board\S5U1C31W74T1\; ..\..\..\..\..\USBStack\INC\; ..\..\..\include\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GNSS_GW_FW_SIDE_A.bin
  ILINK.IlinkOutputFile: GNSS_GW_FW_SIDE_A.out
  ILINK.IlinkIcfFile: config\S1C31W74_flash_A_Side.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\sePeriphLibrary\Device\S1C31W74\IAR\Debug\Exe\sePeriphLibrary.a; ..\..\..\..\..\seFlashLibrary\Device\S1C31W74\IAR\seFlashLibraryS1C31W74Int.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DebugFlashBside (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __TARGET_ARCH_7_M; S1C31W74; GNSS_GW_SIDE_B
  OBJCOPY.OOCOutputFile: GNSS_GW_FW_SIDE_B.bin
  ILINK.IlinkOutputFile: GNSS_GW_FW_SIDE_B.out
  ILINK.IlinkIcfFile: config\S1C31W74_flash_B_Side.icf
  group (top)
    ../../../: fixed.c main.c usb_config.c
  group apl
    ../../../apl/: man_battery.c man_charge.c man_cmd.c man_data.c man_error.c man_flash.c man_gpio.c man_gps.c man_gyro.c man_http.c man_lte.c man_memory.c man_msg.c man_net.c man_ope.c man_ota.c man_press.c man_rpt.c man_rtc.c man_timer.c man_usb.c man_version.c
  group board
    ../../../../../board/S5U1C31W74T1/: board.c board.h settings.h
    ../../../../../board/S5U1C31W74T1/IAR/: read.c write.c
  group CMSIS
    ../../../../../CMSIS/Device/S1C31W74/Source/IAR/: startup_S1C31W74.s
    ../../../../../CMSIS/Device/S1C31W74/Source/: system_S1C31W74.c
  group common
    ../../../common/: gnss_gw_common.c
  group driver/clg
    ../../../driver/clg/: drv_clg.c
  group driver/flash
    ../../../driver/flash/: drv_flash.c
  group driver/gpio
    ../../../driver/gpio/: drv_gpio.c
  group driver/i2c
    ../../../driver/i2c/: drv_i2c_0.c drv_i2c_1.c
  group driver/rtc
    ../../../driver/rtc/: drv_rtc.c
  group driver/spi
    ../../../driver/spi/: drv_spi_0.c
  group driver/t16
    ../../../driver/t16/: drv_t16_3.c
  group driver/uart
    ../../../driver/uart/: drv_uart2_0.c drv_uart2_1.c
  group driver/usb
    ../../../driver/usb/: drv_usb_main.c drv_usbd_user_cdc_acm.c
  group driver/wdt
    ../../../driver/wdt/: drv_wdt.c
  group hal
    ../../../hal/: ctrl_BQ24160A.c ctrl_BQ28Z610.c ctrl_CXD5600GF.c ctrl_GPIO.c ctrl_I2C0.c ctrl_I2C1.c ctrl_LSM6DSL.c ctrl_MPL3115A2.c ctrl_SLEEP.c ctrl_SM7500JE.c ctrl_USB.c ctrl_W25Q.c
  group middle
    ../../../middle/: mid_GPS.c mid_HTTP.c
  group USBStack
    ../../../../../USBStack/SRC/: usbd_core_cdc.c
  group USBStack/INC
    ../../../../../USBStack/INC/: rl_usb.h usb.h usb_cdc.h usb_def.h usb_for_lib.h usb_hid.h usb_lib.h usb_msc.h usbd_cdc.h usbd_cdc_acm.h usbd_core.h usbd_core_cdc.h usbd_core_hid.h usbd_core_msc.h usbd_desc.h usbd_event.h usbd_hid.h usbd_hw.h usbd_lib_cdc.h usbd_lib_hid.h usbd_lib_msc.h usbd_msc.h version.h
  group USBStack/SRC
    ../../../../../USBStack/SRC/: usbd_cdc_acm.c usbd_core.c usbd_S1C31W74.c

# IAR project seGraphicsLibrary.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S1C31W74 Epson S1C31W74
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: S1C31W74
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: seGraphicsLibrary.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: S1C31W74; NDEBUG
  ICCARM.CCIncludePath2: ; ..\..\..\; $TOOLKIT_DIR$\CMSIS\Include\; $TOOLKIT_DIR$\inc\Epson\; ..\..\..\..\CMSIS\Device\S1C31W74\Include; ..\..\..\..\USBStack\INC\
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../: console_font_4x6.h console_font_4x7.h console_font_5x12.h console_font_5x8.h console_font_6x8.h console_font_8x8.h selcd_draw.c selcd_draw.h selcd_font.c selcd_font.h
